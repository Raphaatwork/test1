# IAR project Backup of TxV2.ewp, settings and files
configuration TxV2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L051K8 ST STM32L051K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L051xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\Src\Debug; ..\Src\Debug\Debug; ..\Src\Debug\ErrorHandling; ..\Src\Defines; ..\Src\Misc; ..\Src\Misc\BatteryLevel; ..\Src\Misc\Calibration; ..\Src\Misc\EEPROM; ..\Src\Misc\LED; ..\Src\Misc\UserButton; ..\Src\S2LP; ..\Src\Tools; ..\Src\Misc\Modes; ..\Src\Misc\Systemboot; ..\Src\Misc\Peripherals; ..\Src\Misc\Peripherals\Lock
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TxV2.hex
  ILINK.IlinkOutputFile: TxV2.out
  ILINK.IlinkIcfFile: stm32l051xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l051xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Application/User/Debug/Debug
    ../Src/Debug/Debug/: Debug.h
  group Application/User/Debug/ErrorHandling
    ../Src/Debug/ErrorHandling/: ErrorHandling.c ErrorHandling.h
  group Application/User/Defines
    ../Src/Defines/: AllParams.c AllParams.h GlobalVariables.c GlobalVariables.h MasterDefine.h
  group Application/User/Misc/BatteryLevel
    ../Src/Misc/BatteryLevel/: BatteryLevel.c BatteryLevel.h
  group Application/User/Misc/Calibration
    ../Src/Misc/Calibration/: LSI.c LSI.h
  group Application/User/Misc/EEPROM
    ../Src/Misc/EEPROM/: Eeprom.c Eeprom.h
  group Application/User/Misc/LED
    ../Src/Misc/LED/: Led.c Led.h
  group Application/User/Misc/Modes
    ../Src/Misc/Modes/: Sleepmode.c Sleepmode.h Wake.c Wake.h
  group Application/User/Misc/Peripherals
    ../Src/Misc/Peripherals/: ADC.c ADC.h CRC.c CRC.h GPIO.c GPIO.h RTC.c RTC.h SPI.c SPI.h UART_RSL.c UART_RSL.h UART_S2.c UART_S2.h Watchdog.c Watchdog.h
  group Application/User/Misc/Peripherals/Lock
    ../Src/Misc/Peripherals/Lock/: PeripheralLock.c PeripheralLock.h
  group Application/User/Misc/Systemboot
    ../Src/Misc/Systemboot/: Boot.c Boot.h
  group Application/User/Misc/UserButton
    ../Src/Misc/UserButton/: UserButton.c UserButton.h
  group Application/User/S2LP
    ../Src/S2LP/: S2LP.c S2LP.h
  group Application/User/Tools
    ../Src/Tools/: Tools.c Tools.h
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
