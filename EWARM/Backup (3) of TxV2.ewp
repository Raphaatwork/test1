# IAR project Backup (3) of TxV2.ewp, settings and files
configuration TxV2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L051K8 ST STM32L051K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L051xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\Src\RSL_Communication; ..\Src\RSL_Communication\Definitions; ..\Src\RSL_Communication\IO; ..\Src\RSL_Communication\IO\Byteebene; ..\Src\RSL_Communication\IO\Nachrichtenebene; ..\Src\RSL_Communication\IO\Nachrichtenstackebene; ..\Src\RSL_Communication\IO\Steuerungablauf; ..\Src\RSL_Communication\IO\Handler; ..\Src\RSL_Communication\UserMethods; ..\Src\RSL_Communication\Declarations; ..\Src\RSL_Communication\Test; ..\Src\RSL_Communication\Behaviour; ..\Src\RSL_Communication\UserBehaviours; ..\Src\RSL_Communication\UserBehaviours\V115Behaviour; ..\Src\RSL_Communication\UserBehaviours\V115Behaviour\BehaviourSteps; ..\Src\Debug; ..\Src\Debug\Debug; ..\Src\Debug\ErrorHandling; ..\Src\Defines; ..\Src; ..\Src\Misc; ..\Src\Peripherals; ..\Src\Peripherals\ADC; ..\Src\Peripherals\CRC; ..\Src\Peripherals\DMA; ..\Src\Peripherals\EEPROM; ..\Src\Peripherals\GPIO; ..\Src\Peripherals\RTC; ..\Src\Peripherals\SPI; ..\Src\Peripherals\UART_RSL; ..\Src\Peripherals\Watchdog; ..\Src\System; ..\Src\System\Batterylevel; ..\Src\System\Bootsource; ..\Src\System\Led; ..\Src\System\Runmodes; ..\Src\System\Userbutton; ..\Src\Application; ..\Src\Application\App_RF_Interfaces; ..\Src\Peripherals\UART_Tester; ..\Src\Application\App_TestingProgramming; ..\Src\System\SafetyModules; ..\Src\S2LP_Communication
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TxV2.hex
  ILINK.IlinkOutputFile: TxV2.out
  ILINK.IlinkIcfFile: stm32l051xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l051xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Application/User/Application
    ../Src/Application/: App.c App.h App_Button_Barrelroll.c App_Button_Barrelroll.h App_Misc.c App_Misc.h App_PowerModeTest.c App_PowerModeTest.h
  group Application/User/Application/App_RF_Interfaces
    ../Src/Application/App_RF_Interfaces/: App_868MHz.c App_868MHz.h App_868MHz_MessageBuilder.c App_868MHz_MessageBuilder.h App_868MHz_Sequencer.c App_868MHz_Sequencer.h App_RSL.c App_RSL.h APP_RSL_Interaction_Broadcast.c APP_RSL_Interaction_Broadcast.h App_RSL_Interaction_Emergency.c App_RSL_Interaction_Emergency.h App_RSL_Interaction_Pairing.c App_RSL_Interaction_Pairing.h
  group Application/User/Application/App_TestingProgramming
    ../Src/Application/App_TestingProgramming/: Tx_CommandExecuter.c Tx_CommandExecuter.h Tx_Interpreter.c Tx_Interpreter.h Tx_Interpreter_Messages.c Tx_Interpreter_Messages.h Tx_Misc.c Tx_Misc.h
  group Application/User/Debug/Debug
    ../Src/Debug/Debug/: Debug.h DebugMain.c DebugMain.h
  group Application/User/Debug/ErrorHandling
    ../Src/Debug/ErrorHandling/: ErrorCodes.h ErrorHandling.c ErrorHandling.h
  group Application/User/Defines
    ../Src/Defines/: AllParams.c AllParams.h GlobalVariables.c GlobalVariables.h MasterDefine.h
  group Application/User/Misc
    ../Src/Misc/: Tools.c Tools.h
  group Application/User/Peripherals/ADC
    ../Src/Peripherals/ADC/: ADC.c ADC.h
  group Application/User/Peripherals/CRC
    ../Src/Peripherals/CRC/: CRC.c CRC.h
  group Application/User/Peripherals/DMA
    ../Src/Peripherals/DMA/: DMA.c DMA.h
  group Application/User/Peripherals/EEPROM
    ../Src/Peripherals/EEPROM/: EEPROM_Access.c EEPROM_Access.h EEPROM_ApplicationMapped.c EEPROM_ApplicationMapped.h EEPROM_Map.c EEPROM_Map.h
  group Application/User/Peripherals/GPIO
    ../Src/Peripherals/GPIO/: GPIO.c GPIO.h
  group Application/User/Peripherals/RTC
    ../Src/Peripherals/RTC/: RTC.c RTC.h
  group Application/User/Peripherals/SPI
    ../Src/Peripherals/SPI/: SPI.c SPI.h
  group Application/User/Peripherals/UART_RSL
    ../Src/Peripherals/UART_RSL/: UART_RSL.c UART_RSL.h
  group Application/User/Peripherals/UART_Tester
    ../Src/Peripherals/UART_Tester/: UART_Tester.c UART_Tester.h
  group Application/User/Peripherals/Watchdog
    ../Src/Peripherals/Watchdog/: Watchdog.c Watchdog.h
  group Application/User/RSL_Communication/Behaviour
    ../Src/RSL_Communication/Behaviour/: BehaviourController.c BehaviourController.h BehaviourDefines.h
  group Application/User/RSL_Communication/Declarations
    ../Src/RSL_Communication/Declarations/: ValidMessages.c ValidMessages.h
  group Application/User/RSL_Communication/Definitions
    ../Src/RSL_Communication/Definitions/: Device_Definitions.h Message_Definitions.h Stack_Definitions.h Variable_Definitions.h
  group Application/User/RSL_Communication/IO/Byteebene
    ../Src/RSL_Communication/IO/Byteebene/: Ringbuffer.c Ringbuffer.h RingbufferWrapper.c RingbufferWrapper.h
  group Application/User/RSL_Communication/IO/Handler
    ../Src/RSL_Communication/IO/Handler/: Handler_NAK_Transmission.c Handler_NAK_Transmission.h Handler_Timer.c Handler_Timer.h
  group Application/User/RSL_Communication/IO/Nachrichtenebene
    ../Src/RSL_Communication/IO/Nachrichtenebene/: CRC_Software.c CRC_Software.h Parser.c Parser.h
  group Application/User/RSL_Communication/IO/Nachrichtenstackebene
    ../Src/RSL_Communication/IO/Nachrichtenstackebene/: MessageIOBuffer.c MessageIOBuffer.h
  group Application/User/RSL_Communication/IO/Steuerungablauf
    ../Src/RSL_Communication/IO/Steuerungablauf/: Logic.c Logic.h
  group Application/User/RSL_Communication/Test
    ../Src/RSL_Communication/Test/: RSL_Protocol_Lower_Level_Test.c RSL_Protocol_Lower_Level_Test.h RSL_Protocol_Upper_Level_Behaviours_Test.c RSL_Protocol_Upper_Level_Behaviours_Test.h RSL_Protocol_Upper_Level_Steps_Test.c RSL_Protocol_Upper_Level_Steps_Test.h Test_Selector.h
  group Application/User/RSL_Communication/UserBehaviours/V115Behaviour
    ../Src/RSL_Communication/UserBehaviours/V115Behaviour/: BehaviourV115_Alert.c BehaviourV115_Alert.h BehaviourV115_AlertBase.c BehaviourV115_AlertBase.h BehaviourV115_Battery.c BehaviourV115_Battery.h BehaviourV115_BC.c BehaviourV115_BC.h BehaviourV115_Error.c BehaviourV115_Error.h BehaviourV115_Pairing.c BehaviourV115_Pairing.h BehaviourV115_ResetAlert.c BehaviourV115_ResetAlert.h BehaviourV115_SetAllCharacteristics.c BehaviourV115_SetAllCharacteristics.h
  group Application/User/RSL_Communication/UserBehaviours/V115Behaviour/BehaviourSteps
    ../Src/RSL_Communication/UserBehaviours/V115Behaviour/BehaviourSteps/: BehaviourStepV115_BC_End.c BehaviourStepV115_BC_End.h BehaviourStepV115_BC_Start.c BehaviourStepV115_BC_Start.h BehaviourStepV115_BC_Wait_TO.c BehaviourStepV115_BC_Wait_TO.h BehaviourStepV115_CharAlert.c BehaviourStepV115_CharAlert.h BehaviourStepV115_CharBattery.c BehaviourStepV115_CharBattery.h BehaviourStepV115_CharError.c BehaviourStepV115_CharError.h BehaviourStepV115_Pairing.c BehaviourStepV115_Pairing.h BehaviourStepV115_RemovePD.c BehaviourStepV115_RemovePD.h BehaviourStepV115_Sleep.c BehaviourStepV115_Sleep.h BehaviourStepV115_Start.c BehaviourStepV115_Start.h
  group Application/User/RSL_Communication/UserMethods
    ../Src/RSL_Communication/UserMethods/: UserMethods_Characteristics.c UserMethods_Characteristics.h UserMethods_RSL10_Control.c UserMethods_RSL10_Control.h UserMethods_UART.c UserMethods_UART.h
  group Application/User/S2LP_Communication
    ../Src/S2LP_Communication/: Bitstuffing.c Bitstuffing.h Headeradd.c Headeradd.h Helperfunction.c Helperfunction.h NRZ.c NRZ.h Protokol_Fehler.c Protokol_Fehler.h S2LP.c S2LP.h S2LP_Configuration.c S2LP_Configuration.h
  group Application/User/System/Batterylevel
    ../Src/System/Batterylevel/: Batterylevel.c Batterylevel.h
  group Application/User/System/Bootsource
    ../Src/System/Bootsource/: Bootsource.c Bootsource.h
  group Application/User/System/Led
    ../Src/System/Led/: Led.c Led.h
  group Application/User/System/Runmodes
    ../Src/System/Runmodes/: Runmode_Awake.c Runmode_Awake.h Runmode_Sleep.c Runmode_Sleep.h Runmode_Watchdog.c Runmode_Watchdog.h
  group Application/User/System/SafetyModules
    ../Src/System/SafetyModules/: EEPROMCheck.c EEPROMCheck.h FlashCheck.c FlashCheck.h
  group Application/User/System/Userbutton
    ../Src/System/Userbutton/: Userbutton.c Userbutton.h
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
